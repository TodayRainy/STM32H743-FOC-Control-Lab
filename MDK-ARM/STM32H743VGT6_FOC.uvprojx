# Keil uVision project STM32H743VGT6_FOC.uvprojx, settings and files
target STM32H743VGT6_FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x807FFFF) IROM2(0x8100000-0x817FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743VGT6_FOC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;./other_file/system_h7;./other_file/bsp;./other_file/usb/user;./other_file/usb/lib/STM32_USB_Device_Library/Class/CDC/Inc;./other_file/usb/lib/STM32_USB_Device_Library/Class/MSC/Inc;./other_file/usb/lib/STM32_USB_Device_Library/Class/COMPLEX;./other_file/usb/lib/STM32_USB_Device_Library/Core/Inc;./other_file/foc;./other_file/dsp_h7;./other_file/debug
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\flash.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c i2c.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group dsp
    ./other_file/dsp_h7/: arm_cortexM7lfdp_math.lib
  group system
    ./other_file/system_h7/: sys_m7.c
  group bsp
    ./other_file/bsp/: bsp.cpp bsp_irq.cpp
    ./other_file/bsp/w25qxx/: w25qxx.cpp
    ./other_file/bsp/adc_dma/: adc_dma.cpp
    ./other_file/bsp/mpu/: mpu.cpp
    ./other_file/bsp/can/: bsp_can.cpp
    ./other_file/bsp/mt6835gt/: mt6835gt.cpp
    ./other_file/bsp/mt6701acd/: mt6701acd.cpp
  group usb/core
    ./other_file/usb/lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group usb/device
    ./other_file/usb/lib/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ./other_file/usb/lib/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./other_file/usb/lib/STM32_USB_Device_Library/Class/COMPLEX/: usbd_complex.c
  group usb/user
    ./other_file/usb/user/: usb_device.c usbd_cdc_desc.c usbd_cdc_interface.c usbd_msc_desc.c usbd_storage.c usbd_conf.c usbd_complex_desc.c
  group debug
    ./other_file/debug/: debug.c
  group foc
    ./other_file/foc/: readme.txt foc_hw.cpp foc_app.cpp foc_motor.cpp foc_math.cpp foc_current.cpp foc_filter.cpp foc_speed.cpp foc_pid.cpp foc_pwm.cpp foc_vf.cpp foc_smo.cpp foc_flux.cpp foc_hfi.cpp foc_abzenc.cpp foc_absenc.cpp foc_ctrl.cpp foc_time.cpp foc_iden.cpp
