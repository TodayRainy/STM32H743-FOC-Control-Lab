# Keil uVision project STM32H743VGT6_FOC.uvprojx, settings and files
target STM32H743VGT6_FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x807FFFF) IROM2(0x8100000-0x817FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743VGT6_FOC +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../system;../app;../app/debug;../port;../driver;../driver/adc_dma;../driver/can;../driver/mpu;../driver/mt6835gt;../driver/mt6701acd;../driver/w25qxx;../algorithm/foc;../algorithm/foc/core;../algorithm/foc/control;../algorithm/foc/modulation;../algorithm/foc/observer;../algorithm/foc/sensor;../algorithm/foc/ident;../third_lib/CMSIS-DSP;../third_lib/usb_user;../third_lib/STM32_USB_Device_Library/Core/Inc;../third_lib/STM32_USB_Device_Library/Class/CDC/Inc;../third_lib/STM32_USB_Device_Library/Class/MSC/Inc;../third_lib/STM32_USB_Device_Library/Class/COMPLEX
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\flash.sct
  group mdk
    ./: startup_stm32h743xx.s
  group firmware/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c i2c.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group firmware/HAL
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group firmware/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group third_lib/CMSIS-DSP
    ../third_lib/CMSIS-DSP/: arm_cortexM7lfdp_math.lib
  group system
    ../system/: sys_m7.c
  group driver
    ../app/: app_init.cpp
    ../driver/w25qxx/: w25qxx.cpp
    ../driver/adc_dma/: adc_dma.cpp
    ../driver/mpu/: mpu.cpp
    ../driver/can/: bsp_can.cpp
    ../port/: irq.cpp
    ../driver/mt6835gt/: mt6835gt.cpp
    ../driver/mt6701acd/: mt6701acd.cpp
  group third_lib/usb/core
    ../third_lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group third_lib/usb/class
    ../third_lib/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../third_lib/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../third_lib/STM32_USB_Device_Library/Class/COMPLEX/: usbd_complex.c
  group third_lib/usb/user
    ../third_lib/usb_user/: usb_device.c usbd_cdc_desc.c usbd_cdc_interface.c usbd_msc_desc.c usbd_storage.c usbd_conf.c usbd_complex_desc.c
  group app
    ../app/debug/: debug.c
  group algorithm/foc
    ../resources/: foc_readme.txt
    ../port/: foc_hw.cpp
    ../app/: foc_app.cpp
    ../algorithm/foc/: foc_motor.cpp foc_current.cpp
    ../algorithm/foc/core/: foc_math.cpp foc_filter.cpp foc_pid.cpp
    ../algorithm/foc/control/: foc_speed.cpp foc_ctrl.cpp foc_time.cpp
    ../algorithm/foc/modulation/: foc_pwm.cpp
    ../algorithm/foc/observer/: foc_vf.cpp foc_smo.cpp foc_flux.cpp foc_hfi.cpp
    ../algorithm/foc/sensor/: foc_abzenc.cpp foc_absenc.cpp
    ../algorithm/foc/ident/: foc_iden.cpp
